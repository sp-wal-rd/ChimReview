# Keil uVision project UiBoard.uvproj, settings and files
target UiBoard (MCS-51)
  device: SC92F8363B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0xFF) CLOCK(16000000)
  output: UiBoard +hex
  c flags: Optimize=8
  c define: SC92F836xB
  c include: ..\FWLib\SC92F_Lib\inc;..\User;..\User\HeadFiles;..\User\global;..\Project\Chimney\Workspace\UiBoard\Keil_C\Project\..\User\global;..\User\stateflow;..\User\hal\wm_UiBoardControl;..\User\hal\wm_gpio_map;..\User\hal\wm_led_control;..\Drivers;..\User\hal\wm_7seg_control;..\User\hal\wm_uart;..\Drivers\TKDriver\C
  link misc: REMOVEUNUSED
  group User
    ../User/hal/wm_7seg_control/: wm_7seg_control.c
    ../User/ril/wm_timed_activity/: wm_timed_activity.c
    ../User/hal/wm_led_control/: wm_led_cntrl.c
    ../User/global/: wm_global.c
    ../User/stateflow/: wm_state_flow.c
    ../User/hal/wm_TouchKeyControl/: wm_tk_cntrl.c
    ../User/hal/wm_uart/: wm_uart.c
    ../User/: main.c SC_Init.c SC_it.c CompCtrlDefine.c CallBackFunction.c
  group Drivers
    ../Drivers/TKDriver/C/: SC92F8X6XB_HighSensitive_lib_T1_L_V2.2.0.LIB TKDriver.C
  group FWLib
    ../FWLib/SC92F_Lib/src/: sc92f_wdt.c sc92f_pwm.c sc92f_gpio.c sc92f_option.c sc92f_timer2.c sc92f_timer1.c
  group Startup
    ./: STARTUP.A51
